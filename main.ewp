# IAR project main.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F247 MSP430F247
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: msp_exp430g2; interface; devices; devices\lcd_dogm128_6; common; cc1120_easyLink_vchip_boosterpack
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: as above
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F247.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group cc1120_easyLink_vchip_boosterpack
    cc1120_easyLink_vchip_boosterpack/: cc1120_vchip_easy_link_reg_config.h cc1120_vchip_easy_link_tx.c
  group common
    common/: hal_defs.h hal_int.c hal_msp430.h hal_types.h
  group devices
    devices/: cc112x_spi.c cc112x_spi.h
  group interface
    interface/: hal_acc.h hal_assert.h hal_button.h hal_digio.h hal_digio2.h hal_int.h hal_joystick.h hal_lcd.h hal_lcd_sblcda4.h hal_lcd_srf04.h hal_led.h hal_lightsensor.h hal_mcu.h hal_potmeter.h hal_rf.h hal_rf_security.h hal_rf_util.h hal_timer.h hal_timer_32k.h hal_uart.h hal_wait.h
  group msp_exp430g2
    msp_exp430g2/: hal_board.c hal_board.h hal_digio2.c hal_int_rf_msp_exp430g2.c hal_int_rf_msp_exp430g2.h hal_msp_exp430g2_spi.c hal_msp_exp430g2_spi.h
